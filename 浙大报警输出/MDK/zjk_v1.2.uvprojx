# Keil uVision project zjk_v1.2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zjk_v1 +hex
  AfterMake: C:\Keil_V5\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/zjk_v1.bin  ./Objects/zjk_v1.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_KEIL
  c include: .\Sources\App;.\Sources\BSP\M3;.\Sources\CMSIS\M3\startup\arm;.\Sources\Driver;.\Sources\LIB\STM32F10x_StdPeriph_Driver\inc;.\Sources\Timer;.\Sources\CMSIS\M3;.\Sources\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./Sources/App/: main.c ascii_protocol.c measure.c public.c rtu_protocol.c
  group BSP
    ./Sources/BSP/: stm32f1_init.c stm32f10x_it.c
  group CMSIS
    ./Sources/CMSIS/M3/: core_cm3.c
    ./Sources/CMSIS/M3/startup/arm/: startup_stm32f10x_md.s
  group Driver
    ./Sources/Driver/: debug.c drv_adc.c drv_crc16.c drv_eeprom.c drv_modbus.c drv_PwmHV.c drv_spi.c drv_uart.c meas_current.c
  group Lib
    ./Sources/LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Timer
    ./Sources/Timer/: my_timer.c
