# Keil uVision project 1602分模块.uvproj, settings and files
target Target 1 (MCS-51)
  device: Core8051 Actel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000)
  output: 1602分模块 +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: 1602.c delay.c main.c HMC5883.c ADXL345.c
